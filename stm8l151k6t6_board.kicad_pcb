# Repository afbravo/stm8l151k6t6_board

File README.md:

# STM8L151 Dev Board

This board was created with the intent to familiarize with the STM8 family of MCUs from ST Microcontroller.
The main features of this board are:

- micro usb power input
- power on led
- user led connected to PB0
- user button connected to PD7
- SWIM programming / debugging interface
- 8MHz High Speed External Clock
- 32.768 KHz Low Speed External Clock
- Reset Button
- General Male Headers for all I/O

The board was created using KiCad 6. It was mostly left up to the end user to decide its purspose
as it doesnt provide any internal sensors or ICs.

The DataSheet for the STM8L151K6T6 MCU:

## Schematic

## PCB

## Finished Board

## KiCad design stm8l151k6t6_board.kicad_pcb

Board: 2 copper layers, 68.4 x 39.4 mm, 31 parts (0 on the bottom side), 36 nets.

Parts:
C1, C2, C4: 1uF; C_0603_1608Metric
C3, C5, C6: 100nF; C_0402_1005Metric
C7, C8, C9, C10: 15pF; C_0402_1005Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3, J4: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J5: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
LED1: RED; LED_0805_2012Metric
PWR: GREEN; LED_0805_2012Metric
R1, R2, R3: 100; R_0603_1608Metric
RST: RESET; SW-SMD_4P-L4.2-W3.2-P2.20-LS4.6
U1: USB_B_Micro; MICRO-USB-SMD_MICRO-7.2JB
U2: TPMIC5504; SOT-23-5
U3: STM8L151K6T6; LQFP-32_7x7mm_P0.8mm
USR: USER; SW-SMD_4P-L4.2-W3.2-P2.20-LS4.6
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 32K768Hz; Crystal_SMD_2012-2Pin_2.0x1.2mm

Connections:
+3V3: C2.1, C4.1, C5.1, C6.1, J1.2, J3.7, J5.1, R1.1, U2.5 (OUT), U3.8 (V_{DD})
+5V: C1.1, U1.1 (VBUS), U2.1 (IN), U2.3 (EN)
/HSE_IN: C7.1, U3.2 (PA2), Y1.1
/HSE_OUT: C9.1, U3.3 (PA3), Y1.3
/LSE_IN: C8.1, U3.30 (PC5), Y2.1
/LSE_OUT: C10.1, U3.31 (PC6), Y2.2
/PA0: J1.8, J5.2, U3.32 (PA0)
/PA1: C3.1, J1.7, J5.4, RST.3, RST.4, U3.1 (PA1/NRST)
/PA4: J1.6, U3.4 (PA4)
/PA5: J1.5, U3.5 (PA5)
/PA6: J1.4, U3.6 (PA6)
/PB0: J2.8, R2.1, U3.13 (PB0)
/PB1: J2.7, U3.14 (PB1)
/PB2: J2.6, U3.15 (PB2)
/PB3: J2.5, U3.16 (PB3)
/PB4: J2.4, U3.17 (PB4)
/PB5: J2.3, U3.18 (PB5)
/PB6: J2.2, U3.19 (PB6)
/PB7: J2.1, U3.20 (PB7)
/PC0: J3.1, U3.25 (PC0)
/PC1: J3.2, U3.26 (PC1)
/PC2: J3.3, U3.27 (PC2)
/PC3: J3.4, U3.28 (PC3)
/PC4: J3.5, U3.29 (PC4)
/PD0: J4.1, U3.9 (PD0)
/PD1: J4.2, U3.10 (PD1)
/PD2: J4.3, U3.11 (PD2)
/PD3: J4.4, U3.12 (PD3)
/PD4: J4.5, U3.21 (PD4)
/PD5: J4.6, U3.22 (PD5)
/PD6: J4.7, U3.23 (PD6)
/PD7: J4.8, U3.24 (PD7), USR.3, USR.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.1, J3.8, J5.3, LED1.1 (K), PWR.1 (K), R3.2, RST.1, RST.2, U1.5 (GND), U1.6 (EP), U1.7 (EP), U1.8 (EP), U1.9 (EP), U2.2 (GND), U2.4 (GND), U3.7 (V_{SS}), Y1.2, Y1.4
unnamed: PWR.2 (A), R1.2
unnamed: LED1.2 (A), R2.2
unnamed: R3.1, USR.1, USR.2

## Commit log

2023-08-02 added readme
2023-08-02 additions to readme
2023-08-02 added images
2023-08-02 added pcb img
2023-09-05 updated version
